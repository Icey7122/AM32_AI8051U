# Keil uVision project AM32_AI8051U.uvproj, settings and files
target AM32 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: AM32_AI8051U +hex
  group Src
    ./Src/: functions.c main.c servo.c sounds.c kiss_telemetry.c
  group 8051u
    ./Mcu/8051u/Src/: commutate.c eeprom.c input.c peripherals.c phaseouts.c stc8051u_it.c mcu.c adc.c uart.c
    ./Src/: ushot.c
  group Lib
    ./Mcu/8051u/Lib/: AI8051U_32_MDU32.LIB AI8051U_32_TFPU.LIB
